FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot-toradex:"

# SRC_URI_colibri-vf-ldms += "file://0001-change-standard-dtb-file-to-ldms.patch"
SRC_URI += "file://0001-change-standard-dtb-file-to-ldms.patch"
